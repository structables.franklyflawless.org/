# Autodesk Inventor part: FRAME_SideWindow
Saved by Autodesk Inventor 2016 (Build 200138000, 138)
## iProperties
Created: 2016-01
Part Number: FRAME_SideWindow
Material: Generic
Document SubType Name: Modeling
Designer: John
Density: 1 g/cm^3
Appearance: Default
Author: John
## Design history (mm, degrees)
feature "SOLID1"
body "Solid1"
