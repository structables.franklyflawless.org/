# Autodesk Inventor part: Leg_Under
Saved by Autodesk Inventor 2016 (Build 200138000, 138)
## iProperties
Created: 2015-11
Part Number: Leg_Under
Material: Generic
Document SubType Name: Modeling
Designer: John
Density: 1 g/cm^3
Appearance: Default
Author: John
## Design history (mm, degrees)
feature "Base1"
body "Solid1"
