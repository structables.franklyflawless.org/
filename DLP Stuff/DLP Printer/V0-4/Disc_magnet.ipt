# Autodesk Inventor part: Disc_magnet
Saved by Autodesk Inventor 2016 (Build 200138000, 138)
## iProperties
Created: 2015-11
Part Number: Disc_magnet
Material: Generic
Document SubType Name: Modeling
Designer: John
Density: 1 g/cm^3
Appearance: Default
Author: John
## Design history (mm, degrees)
feature "SOLID1"
body "Solid1"
